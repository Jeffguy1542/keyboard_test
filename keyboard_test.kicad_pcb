# Repository Jeffguy1542/keyboard_test

File README.md:

# keyboard_test
 Keyboard PCB Test

## KiCad design keyboard_test.kicad_pcb

Parts:
C1: 10u; C_1206_3216Metric
C2, C3, C4: .1u; C_1206_3216Metric
C5, C6: 22p; C_1206_3216Metric
C7: 1u; C_1206_3216Metric
D1, D2, D3, D4: D_Small; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric
MX1, MX2, MX3, MX4: MX-NoLED; MX-1U-NoLED
R1, R4: 10k; R_1206_3216Metric
R2, R3: 22; R_1206_3216Metric
SW1: SW_Push; SKQG-1155865
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
USB1: Molex-0548190589
Y1: Crystal_GND24_Small; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, F1.1, R1.2, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
COL_0: MX1.1 (COL), MX3.1 (COL), U1.29 (PB5)
COL_1: MX2.1 (COL), MX4.1 (COL), U1.28 (PB4)
D+: R2.2, USB1.3 (D+)
D-: R3.1, USB1.4 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, R4.2, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), USB1.1 (GND), USB1.6 (SHIELD), Y1.2, Y1.4
unnamed: C5.1, U1.17 (XTAL1), Y1.1
unnamed: C6.1, U1.16 (XTAL2), Y1.3
unnamed: C7.1, U1.6 (UCAP)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: R1.1, SW1.2, U1.13 (~RESET)
unnamed: R2.1, U1.4 (D+)
unnamed: R3.2, U1.3 (D-)
unnamed: R4.1, U1.33 (~HWB~/PE2)
ROW_0: D1.1 (K), D2.1 (K), U1.30 (PB6)
ROW_1: D3.1 (K), D4.1 (K), U1.27 (PD7)
VCC: F1.2, USB1.5 (VBUS)

Board: 2 copper layers, 62.7 x 38.1 mm, 24 parts (4 on the bottom side), 20 nets.

## Commit log

2020-10-25 Initialize project
2020-10-25 Add submodules
2020-10-25 Added libraries
2020-10-25 Completed schematic
2020-10-25 Layout & routing complete
2020-10-25 Created Gerbers
2020-11-03 Fixed errors
    -Fixed silkscreen error (swapped R1 and C7)
    -Fixed crystal connections & adjusted routing
    -Put gerbers in their own folder
